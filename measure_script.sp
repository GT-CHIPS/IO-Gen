.measure FFT vmg0 FIND v(tout2) AT=1020000000
.measure FFT vmg1 FIND v(tout2) AT=1040000000
.measure FFT vmg2 FIND v(tout2) AT=1060000000
.measure FFT vmg3 FIND v(tout2) AT=1080000000
.measure FFT vmg4 FIND v(tout2) AT=1100000000
.measure FFT vmg5 FIND v(tout2) AT=1120000000
.measure FFT vmg6 FIND v(tout2) AT=1140000000
.measure FFT vmg7 FIND v(tout2) AT=1160000000
.measure FFT vmg8 FIND v(tout2) AT=1180000000
.measure FFT vmg9 FIND v(tout2) AT=1200000000
.measure FFT vmg10 FIND v(tout2) AT=1220000000
.measure FFT vmg11 FIND v(tout2) AT=1240000000
.measure FFT vmg12 FIND v(tout2) AT=1260000000
.measure FFT vmg13 FIND v(tout2) AT=1280000000
.measure FFT vmg14 FIND v(tout2) AT=1300000000
.measure FFT vmg15 FIND v(tout2) AT=1320000000
.measure FFT vmg16 FIND v(tout2) AT=1340000000
.measure FFT vmg17 FIND v(tout2) AT=1360000000
.measure FFT vmg18 FIND v(tout2) AT=1380000000
.measure FFT vmg19 FIND v(tout2) AT=1400000000
.measure FFT vmg20 FIND v(tout2) AT=1420000000
.measure FFT vmg21 FIND v(tout2) AT=1440000000
.measure FFT vmg22 FIND v(tout2) AT=1460000000
.measure FFT vmg23 FIND v(tout2) AT=1480000000
.measure FFT vmg24 FIND v(tout2) AT=1500000000
.measure FFT vmg25 FIND v(tout2) AT=1520000000
.measure FFT vmg26 FIND v(tout2) AT=1540000000
.measure FFT vmg27 FIND v(tout2) AT=1560000000
.measure FFT vmg28 FIND v(tout2) AT=1580000000
.measure FFT vmg29 FIND v(tout2) AT=1600000000
.measure FFT vmg30 FIND v(tout2) AT=1620000000
.measure FFT vmg31 FIND v(tout2) AT=1640000000
.measure FFT vmg32 FIND v(tout2) AT=1660000000
.measure FFT vmg33 FIND v(tout2) AT=1680000000
.measure FFT vmg34 FIND v(tout2) AT=1700000000
.measure FFT vmg35 FIND v(tout2) AT=1720000000
.measure FFT vmg36 FIND v(tout2) AT=1740000000
.measure FFT vmg37 FIND v(tout2) AT=1760000000
.measure FFT vmg38 FIND v(tout2) AT=1780000000
.measure FFT vmg39 FIND v(tout2) AT=1800000000
.measure FFT vmg40 FIND v(tout2) AT=1820000000
.measure FFT vmg41 FIND v(tout2) AT=1840000000
.measure FFT vmg42 FIND v(tout2) AT=1860000000
.measure FFT vmg43 FIND v(tout2) AT=1880000000
.measure FFT vmg44 FIND v(tout2) AT=1900000000
.measure FFT vmg45 FIND v(tout2) AT=1920000000
.measure FFT vmg46 FIND v(tout2) AT=1940000000
.measure FFT vmg47 FIND v(tout2) AT=1960000000
.measure FFT vmg48 FIND v(tout2) AT=1980000000
.measure FFT vmg49 FIND v(tout2) AT=2020000000
.measure FFT vmg50 FIND v(tout2) AT=2040000000
.measure FFT vmg51 FIND v(tout2) AT=2060000000
.measure FFT vmg52 FIND v(tout2) AT=2080000000
.measure FFT vmg53 FIND v(tout2) AT=2100000000
.measure FFT vmg54 FIND v(tout2) AT=2120000000
.measure FFT vmg55 FIND v(tout2) AT=2140000000
.measure FFT vmg56 FIND v(tout2) AT=2160000000
.measure FFT vmg57 FIND v(tout2) AT=2180000000
.measure FFT vmg58 FIND v(tout2) AT=2200000000
.measure FFT vmg59 FIND v(tout2) AT=2220000000
.measure FFT vmg60 FIND v(tout2) AT=2240000000
.measure FFT vmg61 FIND v(tout2) AT=2260000000
.measure FFT vmg62 FIND v(tout2) AT=2280000000
.measure FFT vmg63 FIND v(tout2) AT=2300000000
.measure FFT vmg64 FIND v(tout2) AT=2320000000
.measure FFT vmg65 FIND v(tout2) AT=2340000000
.measure FFT vmg66 FIND v(tout2) AT=2360000000
.measure FFT vmg67 FIND v(tout2) AT=2380000000
.measure FFT vmg68 FIND v(tout2) AT=2400000000
.measure FFT vmg69 FIND v(tout2) AT=2420000000
.measure FFT vmg70 FIND v(tout2) AT=2440000000
.measure FFT vmg71 FIND v(tout2) AT=2460000000
.measure FFT vmg72 FIND v(tout2) AT=2480000000
.measure FFT vmg73 FIND v(tout2) AT=2500000000
.measure FFT vmg74 FIND v(tout2) AT=2520000000
.measure FFT vmg75 FIND v(tout2) AT=2540000000
.measure FFT vmg76 FIND v(tout2) AT=2560000000
.measure FFT vmg77 FIND v(tout2) AT=2580000000
.measure FFT vmg78 FIND v(tout2) AT=2600000000
.measure FFT vmg79 FIND v(tout2) AT=2620000000
.measure FFT vmg80 FIND v(tout2) AT=2640000000
.measure FFT vmg81 FIND v(tout2) AT=2660000000
.measure FFT vmg82 FIND v(tout2) AT=2680000000
.measure FFT vmg83 FIND v(tout2) AT=2700000000
.measure FFT vmg84 FIND v(tout2) AT=2720000000
.measure FFT vmg85 FIND v(tout2) AT=2740000000
.measure FFT vmg86 FIND v(tout2) AT=2760000000
.measure FFT vmg87 FIND v(tout2) AT=2780000000
.measure FFT vmg88 FIND v(tout2) AT=2800000000
.measure FFT vmg89 FIND v(tout2) AT=2820000000
.measure FFT vmg90 FIND v(tout2) AT=2840000000
.measure FFT vmg91 FIND v(tout2) AT=2860000000
.measure FFT vmg92 FIND v(tout2) AT=2880000000
.measure FFT vmg93 FIND v(tout2) AT=2900000000
.measure FFT vmg94 FIND v(tout2) AT=2920000000
.measure FFT vmg95 FIND v(tout2) AT=2940000000
.measure FFT vmg96 FIND v(tout2) AT=2960000000
.measure FFT vmg97 FIND v(tout2) AT=2980000000
.measure FFT vmg98 FIND v(tout2) AT=3020000000
.measure FFT vmg99 FIND v(tout2) AT=3040000000
.measure FFT vmg100 FIND v(tout2) AT=3060000000
.measure FFT vmg101 FIND v(tout2) AT=3080000000
.measure FFT vmg102 FIND v(tout2) AT=3100000000
.measure FFT vmg103 FIND v(tout2) AT=3120000000
.measure FFT vmg104 FIND v(tout2) AT=3140000000
.measure FFT vmg105 FIND v(tout2) AT=3160000000
.measure FFT vmg106 FIND v(tout2) AT=3180000000
.measure FFT vmg107 FIND v(tout2) AT=3200000000
.measure FFT vmg108 FIND v(tout2) AT=3220000000
.measure FFT vmg109 FIND v(tout2) AT=3240000000
.measure FFT vmg110 FIND v(tout2) AT=3260000000
.measure FFT vmg111 FIND v(tout2) AT=3280000000
.measure FFT vmg112 FIND v(tout2) AT=3300000000
.measure FFT vmg113 FIND v(tout2) AT=3320000000
.measure FFT vmg114 FIND v(tout2) AT=3340000000
.measure FFT vmg115 FIND v(tout2) AT=3360000000
.measure FFT vmg116 FIND v(tout2) AT=3380000000
.measure FFT vmg117 FIND v(tout2) AT=3400000000
.measure FFT vmg118 FIND v(tout2) AT=3420000000
.measure FFT vmg119 FIND v(tout2) AT=3440000000
.measure FFT vmg120 FIND v(tout2) AT=3460000000
.measure FFT vmg121 FIND v(tout2) AT=3480000000
.measure FFT vmg122 FIND v(tout2) AT=3500000000
.measure FFT vmg123 FIND v(tout2) AT=3520000000
.measure FFT vmg124 FIND v(tout2) AT=3540000000
.measure FFT vmg125 FIND v(tout2) AT=3560000000
.measure FFT vmg126 FIND v(tout2) AT=3580000000
.measure FFT vmg127 FIND v(tout2) AT=3600000000
.measure FFT vmg128 FIND v(tout2) AT=3620000000
.measure FFT vmg129 FIND v(tout2) AT=3640000000
.measure FFT vmg130 FIND v(tout2) AT=3660000000
.measure FFT vmg131 FIND v(tout2) AT=3680000000
.measure FFT vmg132 FIND v(tout2) AT=3700000000
.measure FFT vmg133 FIND v(tout2) AT=3720000000
.measure FFT vmg134 FIND v(tout2) AT=3740000000
.measure FFT vmg135 FIND v(tout2) AT=3760000000
.measure FFT vmg136 FIND v(tout2) AT=3780000000
.measure FFT vmg137 FIND v(tout2) AT=3800000000
.measure FFT vmg138 FIND v(tout2) AT=3820000000
.measure FFT vmg139 FIND v(tout2) AT=3840000000
.measure FFT vmg140 FIND v(tout2) AT=3860000000
.measure FFT vmg141 FIND v(tout2) AT=3880000000
.measure FFT vmg142 FIND v(tout2) AT=3900000000
.measure FFT vmg143 FIND v(tout2) AT=3920000000
.measure FFT vmg144 FIND v(tout2) AT=3940000000
.measure FFT vmg145 FIND v(tout2) AT=3960000000
.measure FFT vmg146 FIND v(tout2) AT=3980000000
.measure FFT vmg147 FIND v(tout2) AT=4020000000
.measure FFT vmg148 FIND v(tout2) AT=4040000000
.measure FFT vmg149 FIND v(tout2) AT=4060000000
.measure FFT vmg150 FIND v(tout2) AT=4080000000
.measure FFT vmg151 FIND v(tout2) AT=4100000000
.measure FFT vmg152 FIND v(tout2) AT=4120000000
.measure FFT vmg153 FIND v(tout2) AT=4140000000
.measure FFT vmg154 FIND v(tout2) AT=4160000000
.measure FFT vmg155 FIND v(tout2) AT=4180000000
.measure FFT vmg156 FIND v(tout2) AT=4200000000
.measure FFT vmg157 FIND v(tout2) AT=4220000000
.measure FFT vmg158 FIND v(tout2) AT=4240000000
.measure FFT vmg159 FIND v(tout2) AT=4260000000
.measure FFT vmg160 FIND v(tout2) AT=4280000000
.measure FFT vmg161 FIND v(tout2) AT=4300000000
.measure FFT vmg162 FIND v(tout2) AT=4320000000
.measure FFT vmg163 FIND v(tout2) AT=4340000000
.measure FFT vmg164 FIND v(tout2) AT=4360000000
.measure FFT vmg165 FIND v(tout2) AT=4380000000
.measure FFT vmg166 FIND v(tout2) AT=4400000000
.measure FFT vmg167 FIND v(tout2) AT=4420000000
.measure FFT vmg168 FIND v(tout2) AT=4440000000
.measure FFT vmg169 FIND v(tout2) AT=4460000000
.measure FFT vmg170 FIND v(tout2) AT=4480000000
.measure FFT vmg171 FIND v(tout2) AT=4500000000
.measure FFT vmg172 FIND v(tout2) AT=4520000000
.measure FFT vmg173 FIND v(tout2) AT=4540000000
.measure FFT vmg174 FIND v(tout2) AT=4560000000
.measure FFT vmg175 FIND v(tout2) AT=4580000000
.measure FFT vmg176 FIND v(tout2) AT=4600000000
.measure FFT vmg177 FIND v(tout2) AT=4620000000
.measure FFT vmg178 FIND v(tout2) AT=4640000000
.measure FFT vmg179 FIND v(tout2) AT=4660000000
.measure FFT vmg180 FIND v(tout2) AT=4680000000
.measure FFT vmg181 FIND v(tout2) AT=4700000000
.measure FFT vmg182 FIND v(tout2) AT=4720000000
.measure FFT vmg183 FIND v(tout2) AT=4740000000
.measure FFT vmg184 FIND v(tout2) AT=4760000000
.measure FFT vmg185 FIND v(tout2) AT=4780000000
.measure FFT vmg186 FIND v(tout2) AT=4800000000
.measure FFT vmg187 FIND v(tout2) AT=4820000000
.measure FFT vmg188 FIND v(tout2) AT=4840000000
.measure FFT vmg189 FIND v(tout2) AT=4860000000
.measure FFT vmg190 FIND v(tout2) AT=4880000000
.measure FFT vmg191 FIND v(tout2) AT=4900000000
.measure FFT vmg192 FIND v(tout2) AT=4920000000
.measure FFT vmg193 FIND v(tout2) AT=4940000000
.measure FFT vmg194 FIND v(tout2) AT=4960000000
.measure FFT vmg195 FIND v(tout2) AT=4980000000
.measure FFT vmg196 FIND v(tout2) AT=5020000000
.measure FFT vmg197 FIND v(tout2) AT=5040000000
.measure FFT vmg198 FIND v(tout2) AT=5060000000
.measure FFT vmg199 FIND v(tout2) AT=5080000000
.measure FFT vmg200 FIND v(tout2) AT=5100000000
.measure FFT vmg201 FIND v(tout2) AT=5120000000
.measure FFT vmg202 FIND v(tout2) AT=5140000000
.measure FFT vmg203 FIND v(tout2) AT=5160000000
.measure FFT vmg204 FIND v(tout2) AT=5180000000
.measure FFT vmg205 FIND v(tout2) AT=5200000000
.measure FFT vmg206 FIND v(tout2) AT=5220000000
.measure FFT vmg207 FIND v(tout2) AT=5240000000
.measure FFT vmg208 FIND v(tout2) AT=5260000000
.measure FFT vmg209 FIND v(tout2) AT=5280000000
.measure FFT vmg210 FIND v(tout2) AT=5300000000
.measure FFT vmg211 FIND v(tout2) AT=5320000000
.measure FFT vmg212 FIND v(tout2) AT=5340000000
.measure FFT vmg213 FIND v(tout2) AT=5360000000
.measure FFT vmg214 FIND v(tout2) AT=5380000000
.measure FFT vmg215 FIND v(tout2) AT=5400000000
.measure FFT vmg216 FIND v(tout2) AT=5420000000
.measure FFT vmg217 FIND v(tout2) AT=5440000000
.measure FFT vmg218 FIND v(tout2) AT=5460000000
.measure FFT vmg219 FIND v(tout2) AT=5480000000
.measure FFT vmg220 FIND v(tout2) AT=5500000000
.measure FFT vmg221 FIND v(tout2) AT=5520000000
.measure FFT vmg222 FIND v(tout2) AT=5540000000
.measure FFT vmg223 FIND v(tout2) AT=5560000000
.measure FFT vmg224 FIND v(tout2) AT=5580000000
.measure FFT vmg225 FIND v(tout2) AT=5600000000
.measure FFT vmg226 FIND v(tout2) AT=5620000000
.measure FFT vmg227 FIND v(tout2) AT=5640000000
.measure FFT vmg228 FIND v(tout2) AT=5660000000
.measure FFT vmg229 FIND v(tout2) AT=5680000000
.measure FFT vmg230 FIND v(tout2) AT=5700000000
.measure FFT vmg231 FIND v(tout2) AT=5720000000
.measure FFT vmg232 FIND v(tout2) AT=5740000000
.measure FFT vmg233 FIND v(tout2) AT=5760000000
.measure FFT vmg234 FIND v(tout2) AT=5780000000
.measure FFT vmg235 FIND v(tout2) AT=5800000000
.measure FFT vmg236 FIND v(tout2) AT=5820000000
.measure FFT vmg237 FIND v(tout2) AT=5840000000
.measure FFT vmg238 FIND v(tout2) AT=5860000000
.measure FFT vmg239 FIND v(tout2) AT=5880000000
.measure FFT vmg240 FIND v(tout2) AT=5900000000
.measure FFT vmg241 FIND v(tout2) AT=5920000000
.measure FFT vmg242 FIND v(tout2) AT=5940000000
.measure FFT vmg243 FIND v(tout2) AT=5960000000
.measure FFT vmg244 FIND v(tout2) AT=5980000000
.measure FFT vmg245 FIND v(tout2) AT=6020000000
.measure FFT vmg246 FIND v(tout2) AT=6040000000
.measure FFT vmg247 FIND v(tout2) AT=6060000000
.measure FFT vmg248 FIND v(tout2) AT=6080000000
.measure FFT vmg249 FIND v(tout2) AT=6100000000
.measure FFT vmg250 FIND v(tout2) AT=6120000000
.measure FFT vmg251 FIND v(tout2) AT=6140000000
.measure FFT vmg252 FIND v(tout2) AT=6160000000
.measure FFT vmg253 FIND v(tout2) AT=6180000000
.measure FFT vmg254 FIND v(tout2) AT=6200000000
.measure FFT vmg255 FIND v(tout2) AT=6220000000
.measure FFT vmg256 FIND v(tout2) AT=6240000000
.measure FFT vmg257 FIND v(tout2) AT=6260000000
.measure FFT vmg258 FIND v(tout2) AT=6280000000
.measure FFT vmg259 FIND v(tout2) AT=6300000000
.measure FFT vmg260 FIND v(tout2) AT=6320000000
.measure FFT vmg261 FIND v(tout2) AT=6340000000
.measure FFT vmg262 FIND v(tout2) AT=6360000000
.measure FFT vmg263 FIND v(tout2) AT=6380000000
.measure FFT vmg264 FIND v(tout2) AT=6400000000
.measure FFT vmg265 FIND v(tout2) AT=6420000000
.measure FFT vmg266 FIND v(tout2) AT=6440000000
.measure FFT vmg267 FIND v(tout2) AT=6460000000
.measure FFT vmg268 FIND v(tout2) AT=6480000000
.measure FFT vmg269 FIND v(tout2) AT=6500000000
.measure FFT vmg270 FIND v(tout2) AT=6520000000
.measure FFT vmg271 FIND v(tout2) AT=6540000000
.measure FFT vmg272 FIND v(tout2) AT=6560000000
.measure FFT vmg273 FIND v(tout2) AT=6580000000
.measure FFT vmg274 FIND v(tout2) AT=6600000000
.measure FFT vmg275 FIND v(tout2) AT=6620000000
.measure FFT vmg276 FIND v(tout2) AT=6640000000
.measure FFT vmg277 FIND v(tout2) AT=6660000000
.measure FFT vmg278 FIND v(tout2) AT=6680000000
.measure FFT vmg279 FIND v(tout2) AT=6700000000
.measure FFT vmg280 FIND v(tout2) AT=6720000000
.measure FFT vmg281 FIND v(tout2) AT=6740000000
.measure FFT vmg282 FIND v(tout2) AT=6760000000
.measure FFT vmg283 FIND v(tout2) AT=6780000000
.measure FFT vmg284 FIND v(tout2) AT=6800000000
.measure FFT vmg285 FIND v(tout2) AT=6820000000
.measure FFT vmg286 FIND v(tout2) AT=6840000000
.measure FFT vmg287 FIND v(tout2) AT=6860000000
.measure FFT vmg288 FIND v(tout2) AT=6880000000
.measure FFT vmg289 FIND v(tout2) AT=6900000000
.measure FFT vmg290 FIND v(tout2) AT=6920000000
.measure FFT vmg291 FIND v(tout2) AT=6940000000
.measure FFT vmg292 FIND v(tout2) AT=6960000000
.measure FFT vmg293 FIND v(tout2) AT=6980000000
.measure FFT vmg294 FIND v(tout2) AT=7020000000
.measure FFT vmg295 FIND v(tout2) AT=7040000000
.measure FFT vmg296 FIND v(tout2) AT=7060000000
.measure FFT vmg297 FIND v(tout2) AT=7080000000
.measure FFT vmg298 FIND v(tout2) AT=7100000000
.measure FFT vmg299 FIND v(tout2) AT=7120000000
.measure FFT vmg300 FIND v(tout2) AT=7140000000
.measure FFT vmg301 FIND v(tout2) AT=7160000000
.measure FFT vmg302 FIND v(tout2) AT=7180000000
.measure FFT vmg303 FIND v(tout2) AT=7200000000
.measure FFT vmg304 FIND v(tout2) AT=7220000000
.measure FFT vmg305 FIND v(tout2) AT=7240000000
.measure FFT vmg306 FIND v(tout2) AT=7260000000
.measure FFT vmg307 FIND v(tout2) AT=7280000000
.measure FFT vmg308 FIND v(tout2) AT=7300000000
.measure FFT vmg309 FIND v(tout2) AT=7320000000
.measure FFT vmg310 FIND v(tout2) AT=7340000000
.measure FFT vmg311 FIND v(tout2) AT=7360000000
.measure FFT vmg312 FIND v(tout2) AT=7380000000
.measure FFT vmg313 FIND v(tout2) AT=7400000000
.measure FFT vmg314 FIND v(tout2) AT=7420000000
.measure FFT vmg315 FIND v(tout2) AT=7440000000
.measure FFT vmg316 FIND v(tout2) AT=7460000000
.measure FFT vmg317 FIND v(tout2) AT=7480000000
.measure FFT vmg318 FIND v(tout2) AT=7500000000
.measure FFT vmg319 FIND v(tout2) AT=7520000000
.measure FFT vmg320 FIND v(tout2) AT=7540000000
.measure FFT vmg321 FIND v(tout2) AT=7560000000
.measure FFT vmg322 FIND v(tout2) AT=7580000000
.measure FFT vmg323 FIND v(tout2) AT=7600000000
.measure FFT vmg324 FIND v(tout2) AT=7620000000
.measure FFT vmg325 FIND v(tout2) AT=7640000000
.measure FFT vmg326 FIND v(tout2) AT=7660000000
.measure FFT vmg327 FIND v(tout2) AT=7680000000
.measure FFT vmg328 FIND v(tout2) AT=7700000000
.measure FFT vmg329 FIND v(tout2) AT=7720000000
.measure FFT vmg330 FIND v(tout2) AT=7740000000
.measure FFT vmg331 FIND v(tout2) AT=7760000000
.measure FFT vmg332 FIND v(tout2) AT=7780000000
.measure FFT vmg333 FIND v(tout2) AT=7800000000
.measure FFT vmg334 FIND v(tout2) AT=7820000000
.measure FFT vmg335 FIND v(tout2) AT=7840000000
.measure FFT vmg336 FIND v(tout2) AT=7860000000
.measure FFT vmg337 FIND v(tout2) AT=7880000000
.measure FFT vmg338 FIND v(tout2) AT=7900000000
.measure FFT vmg339 FIND v(tout2) AT=7920000000
.measure FFT vmg340 FIND v(tout2) AT=7940000000
.measure FFT vmg341 FIND v(tout2) AT=7960000000
.measure FFT vmg342 FIND v(tout2) AT=7980000000
.measure FFT vmg343 FIND v(tout2) AT=8020000000
.measure FFT vmg344 FIND v(tout2) AT=8040000000
.measure FFT vmg345 FIND v(tout2) AT=8060000000
.measure FFT vmg346 FIND v(tout2) AT=8080000000
.measure FFT vmg347 FIND v(tout2) AT=8100000000
.measure FFT vmg348 FIND v(tout2) AT=8120000000
.measure FFT vmg349 FIND v(tout2) AT=8140000000
.measure FFT vmg350 FIND v(tout2) AT=8160000000
.measure FFT vmg351 FIND v(tout2) AT=8180000000
.measure FFT vmg352 FIND v(tout2) AT=8200000000
.measure FFT vmg353 FIND v(tout2) AT=8220000000
.measure FFT vmg354 FIND v(tout2) AT=8240000000
.measure FFT vmg355 FIND v(tout2) AT=8260000000
.measure FFT vmg356 FIND v(tout2) AT=8280000000
.measure FFT vmg357 FIND v(tout2) AT=8300000000
.measure FFT vmg358 FIND v(tout2) AT=8320000000
.measure FFT vmg359 FIND v(tout2) AT=8340000000
.measure FFT vmg360 FIND v(tout2) AT=8360000000
.measure FFT vmg361 FIND v(tout2) AT=8380000000
.measure FFT vmg362 FIND v(tout2) AT=8400000000
.measure FFT vmg363 FIND v(tout2) AT=8420000000
.measure FFT vmg364 FIND v(tout2) AT=8440000000
.measure FFT vmg365 FIND v(tout2) AT=8460000000
.measure FFT vmg366 FIND v(tout2) AT=8480000000
.measure FFT vmg367 FIND v(tout2) AT=8500000000
.measure FFT vmg368 FIND v(tout2) AT=8520000000
.measure FFT vmg369 FIND v(tout2) AT=8540000000
.measure FFT vmg370 FIND v(tout2) AT=8560000000
.measure FFT vmg371 FIND v(tout2) AT=8580000000
.measure FFT vmg372 FIND v(tout2) AT=8600000000
.measure FFT vmg373 FIND v(tout2) AT=8620000000
.measure FFT vmg374 FIND v(tout2) AT=8640000000
.measure FFT vmg375 FIND v(tout2) AT=8660000000
.measure FFT vmg376 FIND v(tout2) AT=8680000000
.measure FFT vmg377 FIND v(tout2) AT=8700000000
.measure FFT vmg378 FIND v(tout2) AT=8720000000
.measure FFT vmg379 FIND v(tout2) AT=8740000000
.measure FFT vmg380 FIND v(tout2) AT=8760000000
.measure FFT vmg381 FIND v(tout2) AT=8780000000
.measure FFT vmg382 FIND v(tout2) AT=8800000000
.measure FFT vmg383 FIND v(tout2) AT=8820000000
.measure FFT vmg384 FIND v(tout2) AT=8840000000
.measure FFT vmg385 FIND v(tout2) AT=8860000000
.measure FFT vmg386 FIND v(tout2) AT=8880000000
.measure FFT vmg387 FIND v(tout2) AT=8900000000
.measure FFT vmg388 FIND v(tout2) AT=8920000000
.measure FFT vmg389 FIND v(tout2) AT=8940000000
.measure FFT vmg390 FIND v(tout2) AT=8960000000
.measure FFT vmg391 FIND v(tout2) AT=8980000000
.measure FFT vmg392 FIND v(tout2) AT=9020000000
.measure FFT vmg393 FIND v(tout2) AT=9040000000
.measure FFT vmg394 FIND v(tout2) AT=9060000000
.measure FFT vmg395 FIND v(tout2) AT=9080000000
.measure FFT vmg396 FIND v(tout2) AT=9100000000
.measure FFT vmg397 FIND v(tout2) AT=9120000000
.measure FFT vmg398 FIND v(tout2) AT=9140000000
.measure FFT vmg399 FIND v(tout2) AT=9160000000
.measure FFT vmg400 FIND v(tout2) AT=9180000000
.measure FFT vmg401 FIND v(tout2) AT=9200000000
.measure FFT vmg402 FIND v(tout2) AT=9220000000
.measure FFT vmg403 FIND v(tout2) AT=9240000000
.measure FFT vmg404 FIND v(tout2) AT=9260000000
.measure FFT vmg405 FIND v(tout2) AT=9280000000
.measure FFT vmg406 FIND v(tout2) AT=9300000000
.measure FFT vmg407 FIND v(tout2) AT=9320000000
.measure FFT vmg408 FIND v(tout2) AT=9340000000
.measure FFT vmg409 FIND v(tout2) AT=9360000000
.measure FFT vmg410 FIND v(tout2) AT=9380000000
.measure FFT vmg411 FIND v(tout2) AT=9400000000
.measure FFT vmg412 FIND v(tout2) AT=9420000000
.measure FFT vmg413 FIND v(tout2) AT=9440000000
.measure FFT vmg414 FIND v(tout2) AT=9460000000
.measure FFT vmg415 FIND v(tout2) AT=9480000000
.measure FFT vmg416 FIND v(tout2) AT=9500000000
.measure FFT vmg417 FIND v(tout2) AT=9520000000
.measure FFT vmg418 FIND v(tout2) AT=9540000000
.measure FFT vmg419 FIND v(tout2) AT=9560000000
.measure FFT vmg420 FIND v(tout2) AT=9580000000
.measure FFT vmg421 FIND v(tout2) AT=9600000000
.measure FFT vmg422 FIND v(tout2) AT=9620000000
.measure FFT vmg423 FIND v(tout2) AT=9640000000
.measure FFT vmg424 FIND v(tout2) AT=9660000000
.measure FFT vmg425 FIND v(tout2) AT=9680000000
.measure FFT vmg426 FIND v(tout2) AT=9700000000
.measure FFT vmg427 FIND v(tout2) AT=9720000000
.measure FFT vmg428 FIND v(tout2) AT=9740000000
.measure FFT vmg429 FIND v(tout2) AT=9760000000
.measure FFT vmg430 FIND v(tout2) AT=9780000000
.measure FFT vmg431 FIND v(tout2) AT=9800000000
.measure FFT vmg432 FIND v(tout2) AT=9820000000
.measure FFT vmg433 FIND v(tout2) AT=9840000000
.measure FFT vmg434 FIND v(tout2) AT=9860000000
.measure FFT vmg435 FIND v(tout2) AT=9880000000
.measure FFT vmg436 FIND v(tout2) AT=9900000000
.measure FFT vmg437 FIND v(tout2) AT=9920000000
.measure FFT vmg438 FIND v(tout2) AT=9940000000
.measure FFT vmg439 FIND v(tout2) AT=9960000000
.measure FFT vmg440 FIND v(tout2) AT=9980000000

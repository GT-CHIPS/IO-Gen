.INCLUDE './pckg_GSSSG/RLGC_Case2.inc'
